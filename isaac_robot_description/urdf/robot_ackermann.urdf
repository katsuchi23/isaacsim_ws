Commit message: adding camera and fix urdf

File: isaac_robot_description/urdf/robot_ackermann.urdf (robot description, URDF)
Before this commit: robot isaac_bot, 6 links, 5 joints
Joints:
- joint lidar_joint: origin xyz=0 0 0.12 rpy=0 0 0 -> xyz=0 0 0.17 rpy=0 0 0
